# Keil uVision project Project_GPS.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_GPS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group headers
    ./headers/: Buzzer.h GPS.h LCD.h tm4c123gh6pm.h UART.h
  group source
    ./source/: Buzzer.c GPS.c LCD.c main.c UART.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.1
